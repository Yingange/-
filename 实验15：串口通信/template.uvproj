# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LP213 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(20000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SRC
  group Source Group 1
    ./: main.c
    ./SRC/: oled.c
